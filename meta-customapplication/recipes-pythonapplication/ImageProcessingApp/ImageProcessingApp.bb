SUMMARY = "Python application for Image Processing"
DESCRIPTION = "Recipe created by bitbake-layers"
LICENSE = "MIT"

python do_build() {
    bb.plain("***********************************************");
    bb.plain("*                                             *");
    bb.plain("*  Python application   *");
    bb.plain("*                                             *");
    bb.plain("***********************************************");
}
